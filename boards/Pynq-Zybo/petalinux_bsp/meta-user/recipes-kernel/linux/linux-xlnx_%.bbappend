SRC_URI += "file://webcam_enable.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

