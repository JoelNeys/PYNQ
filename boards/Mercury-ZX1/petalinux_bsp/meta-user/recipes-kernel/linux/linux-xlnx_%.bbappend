SRC_URI += "file://micrel_phy.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

