SRC_URI += "file://micrel_phy.cfg"
SRC_URI += "file://proc.cfg"
SRC_URI += "file://pci.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

